# Keil uVision project MPU6050.uvprojx, settings and files
target MPU6050 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: MPU6050 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F1
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./Inc;./Src;./MPU6050_DMP;./MPU6050_DMP/driver/eMPL;./MPU6050_DMP/driver/include;./MPU6050_DMP/driver/stm32L;./MPU6050_DMP/eMPL-hal;./MPU6050_DMP/mllite;./MPU6050_DMP/mpl
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group MPU6050_DMP
    ./MPU6050_DMP/mpl/: libmpllib.lib
    ./MPU6050_DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./MPU6050_DMP/driver/stm32L/: log_stm32.c
    ./MPU6050_DMP/eMPL-hal/: eMPL_outputs.c
    ./MPU6050_DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./MPU6050_DMP/: MPU6050.c MPU6050.h
  group Inc
    ./Inc/: OLED.h OLED_Data.h
  group Src
    ./Src/: OLED.c OLED_Data.c
software components: CMSIS:CORE 4.3.0
